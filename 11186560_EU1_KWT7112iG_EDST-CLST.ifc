Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-05-28T09:51:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 28 09:51:02 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{CA8C4C6B-1B47-4BD9-B97E-137F7CEC24D1}\ifc * Database version: 5507 * Database creation date: Tue May 28 09:51:01 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 28 09:51:01 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 28 09:51:01 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 36711200_EU1_11186560_KWT7112iG_EDST-CLST, 11186560_EU1_KWT7112iG_EDST-CLST:36711200_EU1_11186560_KWT7112iG_EDST-CLST:205678
In: Level 1
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Design_Glass, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, Spruce, Polypropylene
Pset_BuildingElementProxyCommon - Reference: 36711200_EU1_11186560_KWT7112iG_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
